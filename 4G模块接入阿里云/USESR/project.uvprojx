# Keil uVision project project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\USESR;..\MYCOED;..\MYCOED\BH1750;..\MYCOED\EC600S
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWLIB
    ../FWLIB/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c
  group USESR
    ./: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group MYCOED
    ../MYCOED/: main.c led.c delay.c usart.c exti.c
    ../MYCOED/BH1750/: bh1750.c
    ../MYCOED/EC600S/: EC600S.c
